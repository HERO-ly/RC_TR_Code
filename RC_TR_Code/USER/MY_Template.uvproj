# Keil uVision project MY_Template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MY_Template +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F4MCU\FWLIB\inc;..\STM32F4MCU\SYSTEM\usart;..\STM32F4MCU\CORE;..\STM32F4MCU\SYSTEM\sys;..\STM32F4MCU\SYSTEM\delay;..\ROBOT\BSP;..\ROBOT\ALGO;..\ROBOT\ANALYSIS;..\ROBOT\APP;..\USER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c
  group STM32F4MCU
    ../STM32F4MCU/SYSTEM/usart/: usart.c
    ../STM32F4MCU/SYSTEM/delay/: delay.c
    ../STM32F4MCU/SYSTEM/sys/: sys.c
    ../STM32F4MCU/FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_iwdg.c
    ../STM32F4MCU/CORE/: startup_stm32f40_41xxx.s
    ./: stm32f4xx_it.c system_stm32f4xx.c
  group APP
    ../ROBOT/APP/: move.c control.c protect.c abs_angle.c
  group BSP
    ../ROBOT/BSP/: led.c timer.c bsp.c can1.c can2.c key.c dma1.c gpio.c
  group ANALYSIS
    ../ROBOT/ANALYSIS/: rxanalysis.c CRC_check.c ni_analysis.c
  group ALGO
    ../ROBOT/ALGO/: pid.c
